# Keil uVision project Project.uvprojx, settings and files
target STM32746ZG_Nucleo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F746xx,USE_HAL_DRIVER,USE_STM32F7XX_NUCLEO_144,ADAFRUIT_TFT_JOY_SD_ID802
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32F7xx_Nucleo_144;../../../../Drivers/BSP/Adafruit_Shield;../../../../Middlewares/Third_Party/FatFs/src
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/User
    ../Src/: fatfs_storage.c main.c stm32f7xx_it.c
  group Middlewares/FatFs/Option
    ../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/BSP/STM32F7xx_Nucleo_144
    ../../../../Drivers/BSP/STM32F7xx_Nucleo_144/: stm32f7xx_nucleo_144.c
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/st7735/: st7735.c
  group Middlewares/FatFs/Core
    ../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Drivers/BSP/Adafruit_Shield
    ../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_sd.c stm32_adafruit_lcd.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_adc_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_gpio.c stm32f7xx_hal_adc.c stm32f7xx_hal_rcc.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_rcc_ex.c
  group Middlewares/FatFs/Drivers
    ../Src/: sd_diskio.c
software components: CMSIS:CORE 4.3.0
