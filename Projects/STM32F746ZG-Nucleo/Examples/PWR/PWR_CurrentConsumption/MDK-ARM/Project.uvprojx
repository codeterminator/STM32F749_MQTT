# Keil uVision project Project.uvprojx, settings and files
target STM32746ZG_Nucleo (ARM-ADS)
  device: STM32F746ZGTx STMicroelectronics
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32746ZG_Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F746xx,USE_HAL_DRIVER,USE_STM32F7XX_NUCLEO_144
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F7xx_Nucleo_144
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F7xx_Nucleo_144
    ../../../../../../Drivers/BSP/STM32F7xx_Nucleo_144/: stm32f7xx_nucleo_144.c
  group Example/MDK-ARM
    ./: startup_stm32f746xx.s
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_spi.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_gpio.c stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_pwr.c
  group Example/User
    ../Src/: stm32f7xx_lp_modes.c stm32f7xx_hal_msp.c stm32f7xx_it.c main.c
software components: CMSIS:CORE 4.3.0
